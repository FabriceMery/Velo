# Keil uVision project ElectronicCounter_s140.uvprojx, settings and files
target nrf52840_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_COUNTER CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192 CONFIG_NFCT_PINS_AS_GPIOS
  c misc: --reduce_paths
  c include: ..\config;..\nRF5_SDK_17.1.0_ddde560\components;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_advertising;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_dtm;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_link_ctx_manager;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_racp;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ancs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ans_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_bas;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_bas_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_cscs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_cts_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_dfu;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_dis;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_gls;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hids;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hrs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hrs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hts;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ias;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ias_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lbs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lbs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lls;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_nus;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_nus_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_rscs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_rscs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_tps;..\nRF5_SDK_17.1.0_ddde560\components\ble\common;..\nRF5_SDK_17.1.0_ddde560\components\ble\nrf_ble_gatt;..\nRF5_SDK_17.1.0_ddde560\components\ble\nrf_ble_qwr;..\nRF5_SDK_17.1.0_ddde560\components\ble\peer_manager;..\nRF5_SDK_17.1.0_ddde560\components\boards;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic_fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic_flags;..\nRF5_SDK_17.1.0_ddde560\components\libraries\balloc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bsp;..\nRF5_SDK_17.1.0_ddde560\components\libraries\button;..\nRF5_SDK_17.1.0_ddde560\components\libraries\cli;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crc16;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crc32;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crypto;..\nRF5_SDK_17.1.0_ddde560\components\libraries\csense;..\nRF5_SDK_17.1.0_ddde560\components\libraries\csense_drv;..\nRF5_SDK_17.1.0_ddde560\components\libraries\delay;..\nRF5_SDK_17.1.0_ddde560\components\libraries\ecc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_task_manager;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fds;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fstorage;..\nRF5_SDK_17.1.0_ddde560\components\libraries\gfx;..\nRF5_SDK_17.1.0_ddde560\components\libraries\gpiote;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hardfault;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hardfault\nrf52;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hci;..\nRF5_SDK_17.1.0_ddde560\components\libraries\led_softblink;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log\src;..\nRF5_SDK_17.1.0_ddde560\components\libraries\low_power_pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mem_manager;..\nRF5_SDK_17.1.0_ddde560\components\libraries\memobj;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mpu;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mutex;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwr_mgmt;..\nRF5_SDK_17.1.0_ddde560\components\libraries\queue;..\nRF5_SDK_17.1.0_ddde560\components\libraries\ringbuf;..\nRF5_SDK_17.1.0_ddde560\components\libraries\scheduler;..\nRF5_SDK_17.1.0_ddde560\components\libraries\sdcard;..\nRF5_SDK_17.1.0_ddde560\components\libraries\slip;..\nRF5_SDK_17.1.0_ddde560\components\libraries\sortlist;..\nRF5_SDK_17.1.0_ddde560\components\libraries\spi_mngr;..\nRF5_SDK_17.1.0_ddde560\components\libraries\stack_guard;..\nRF5_SDK_17.1.0_ddde560\components\libraries\strerror;..\nRF5_SDK_17.1.0_ddde560\components\libraries\svc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\timer;..\nRF5_SDK_17.1.0_ddde560\components\libraries\twi_mngr;..\nRF5_SDK_17.1.0_ddde560\components\libraries\twi_sensor;..\nRF5_SDK_17.1.0_ddde560\components\libraries\uart;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\audio;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\cdc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\generic;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\kbd;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\mouse;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\msc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\util;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ac_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_oob_advdata;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_pair_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_pair_msg;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\common;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ep_oob_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\hs_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\le_oob_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\generic\message;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\generic\record;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\launchapp;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\parser\message;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\parser\record;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\text;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\uri;..\nRF5_SDK_17.1.0_ddde560\components\nfc\platform;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t2t_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t2t_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\apdu;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\cc_file;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\hl_detection_procedure;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\tlv;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\common;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\s140\headers;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\s140\headers\nrf52;..\nRF5_SDK_17.1.0_ddde560\external\fprintf;..\nRF5_SDK_17.1.0_ddde560\external\segger_rtt;..\nRF5_SDK_17.1.0_ddde560\external\utf_converter;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx\legacy;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\include;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\hal;..\Source;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fstorage
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\nRF5_SDK_17.1.0_ddde560\components;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_advertising;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_dtm;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_link_ctx_manager;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_racp;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ancs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ans_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_bas;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_bas_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_cscs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_cts_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_dfu;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_dis;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_gls;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hids;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hrs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hrs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_hts;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ias;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_ias_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lbs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lbs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_lls;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_nus;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_nus_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_rscs;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_rscs_c;..\nRF5_SDK_17.1.0_ddde560\components\ble\ble_services\ble_tps;..\nRF5_SDK_17.1.0_ddde560\components\ble\common;..\nRF5_SDK_17.1.0_ddde560\components\ble\nrf_ble_gatt;..\nRF5_SDK_17.1.0_ddde560\components\ble\nrf_ble_qwr;..\nRF5_SDK_17.1.0_ddde560\components\ble\peer_manager;..\nRF5_SDK_17.1.0_ddde560\components\boards;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic_fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\atomic_flags;..\nRF5_SDK_17.1.0_ddde560\components\libraries\balloc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bootloader\ble_dfu;..\nRF5_SDK_17.1.0_ddde560\components\libraries\bsp;..\nRF5_SDK_17.1.0_ddde560\components\libraries\button;..\nRF5_SDK_17.1.0_ddde560\components\libraries\cli;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crc16;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crc32;..\nRF5_SDK_17.1.0_ddde560\components\libraries\crypto;..\nRF5_SDK_17.1.0_ddde560\components\libraries\csense;..\nRF5_SDK_17.1.0_ddde560\components\libraries\csense_drv;..\nRF5_SDK_17.1.0_ddde560\components\libraries\delay;..\nRF5_SDK_17.1.0_ddde560\components\libraries\ecc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0_ddde560\components\libraries\experimental_task_manager;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fds;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fifo;..\nRF5_SDK_17.1.0_ddde560\components\libraries\fstorage;..\nRF5_SDK_17.1.0_ddde560\components\libraries\gfx;..\nRF5_SDK_17.1.0_ddde560\components\libraries\gpiote;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hardfault;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hardfault\nrf52;..\nRF5_SDK_17.1.0_ddde560\components\libraries\hci;..\nRF5_SDK_17.1.0_ddde560\components\libraries\led_softblink;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log;..\nRF5_SDK_17.1.0_ddde560\components\libraries\log\src;..\nRF5_SDK_17.1.0_ddde560\components\libraries\low_power_pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mem_manager;..\nRF5_SDK_17.1.0_ddde560\components\libraries\memobj;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mpu;..\nRF5_SDK_17.1.0_ddde560\components\libraries\mutex;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\pwr_mgmt;..\nRF5_SDK_17.1.0_ddde560\components\libraries\queue;..\nRF5_SDK_17.1.0_ddde560\components\libraries\ringbuf;..\nRF5_SDK_17.1.0_ddde560\components\libraries\scheduler;..\nRF5_SDK_17.1.0_ddde560\components\libraries\sdcard;..\nRF5_SDK_17.1.0_ddde560\components\libraries\slip;..\nRF5_SDK_17.1.0_ddde560\components\libraries\sortlist;..\nRF5_SDK_17.1.0_ddde560\components\libraries\spi_mngr;..\nRF5_SDK_17.1.0_ddde560\components\libraries\stack_guard;..\nRF5_SDK_17.1.0_ddde560\components\libraries\strerror;..\nRF5_SDK_17.1.0_ddde560\components\libraries\svc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\timer;..\nRF5_SDK_17.1.0_ddde560\components\libraries\twi_mngr;..\nRF5_SDK_17.1.0_ddde560\components\libraries\twi_sensor;..\nRF5_SDK_17.1.0_ddde560\components\libraries\uart;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\audio;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\cdc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\generic;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\kbd;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\hid\mouse;..\nRF5_SDK_17.1.0_ddde560\components\libraries\usbd\class\msc;..\nRF5_SDK_17.1.0_ddde560\components\libraries\util;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ac_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_oob_advdata;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_pair_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ble_pair_msg;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\common;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\ep_oob_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\hs_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\connection_handover\le_oob_rec;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\generic\message;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\generic\record;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\launchapp;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\parser\message;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\parser\record;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\text;..\nRF5_SDK_17.1.0_ddde560\components\nfc\ndef\uri;..\nRF5_SDK_17.1.0_ddde560\components\nfc\platform;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t2t_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t2t_parser;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_lib;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\apdu;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\cc_file;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\hl_detection_procedure;..\nRF5_SDK_17.1.0_ddde560\components\nfc\t4t_parser\tlv;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\common;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\s140\headers;..\nRF5_SDK_17.1.0_ddde560\components\softdevice\s140\headers\nrf52;..\nRF5_SDK_17.1.0_ddde560\external\fprintf;..\nRF5_SDK_17.1.0_ddde560\external\segger_rtt;..\nRF5_SDK_17.1.0_ddde560\external\utf_converter;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx;..\nRF5_SDK_17.1.0_ddde560\integration\nrfx\legacy;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\drivers\include;..\nRF5_SDK_17.1.0_ddde560\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  link misc: --diag_suppress 6330
  group Application
    ../: main.c
    ../config/: sdk_config.h
    ../Source/: protocol.c Globale.c
    ./: flash.c
  group Board Definition
    ../nRF5_SDK_17.1.0_ddde560/components/boards/: boards.c
  group UTF8/UTF16 converter
    ../nRF5_SDK_17.1.0_ddde560/external/utf_converter/: utf.c
  group nRF_BLE
    ../nRF5_SDK_17.1.0_ddde560/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nRF5_SDK_17.1.0_ddde560/components/ble/ble_advertising/: ble_advertising.c
    ../nRF5_SDK_17.1.0_ddde560/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../nRF5_SDK_17.1.0_ddde560/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../nRF5_SDK_17.1.0_ddde560/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../nRF5_SDK_17.1.0_ddde560/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/soc/: nrfx_atomic.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../nRF5_SDK_17.1.0_ddde560/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/button/: app_button.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/hardfault/: hardfault_implementation.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/atomic_flags/: nrf_atflags.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/atomic/: nrf_atomic.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK_17.1.0_ddde560/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/memobj/: nrf_memobj.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/ringbuf/: nrf_ringbuf.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/sortlist/: nrf_sortlist.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/strerror/: nrf_strerror.c
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
  group nRF_Log
    ../nRF5_SDK_17.1.0_ddde560/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../nRF5_SDK_17.1.0_ddde560/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../nRF5_SDK_17.1.0_ddde560/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s140_nrf52_7.2.0_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.40.3
